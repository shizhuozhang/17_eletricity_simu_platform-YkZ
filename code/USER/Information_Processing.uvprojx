# Keil uVision project Information_Processing.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Information_Processing +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\74HC165;..\HARDWARE\ADC;..\HARDWARE\EXTI;..\HARDWARE\LED_BEEP;..\HARDWARE\TIM;..\HARDWARE\TLC5615;..\HARDWARE\MATH;..\HARDWARE\74HC595;..\MALLOC;..\HARDWARE\WWDG
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/TIM/: time.c
    ../HARDWARE/LED_BEEP/: IO.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/74HC165/: HC165.c
    ../HARDWARE/TLC5615/: TLC5615.c
    ../HARDWARE/MATH/: math.c
    ../HARDWARE/74HC595/: HC595.c
    ../HARDWARE/WWDG/: wwdg.c
  group SYS
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group MALLOC
    ../MALLOC/: malloc.c
